## base_external/Config.in
```kconfig
source "$BR2_EXTERNAL_PROJECT_BASE_PATH/package/aesd-assignments/Config.in"
source "$BR2_EXTERNAL_PROJECT_BASE_PATH/package/ldd/Config.in"
```
